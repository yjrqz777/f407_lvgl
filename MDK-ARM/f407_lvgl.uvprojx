# Keil uVision project f407_lvgl.uvprojx, settings and files
target f407_lvgl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407_lvgl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../My_Lib/ws2812;../My_Lib/st7789v;../My_Lib/lvgl8.3;../My_Lib/lvgl8.3/demo;../My_Lib/lvgl8.3/porting;../My_Lib/lvgl8.3/src;../My_Lib/lvgl8.3/src/core;../My_Lib/lvgl8.3/src/draw;../My_Lib/lvgl8.3/src/extra;../My_Lib/lvgl8.3/src/font;../My_Lib/lvgl8.3/src/hal;../My_Lib/lvgl8.3/src/misc;../My_Lib/lvgl8.3/src/widgets;../My_Lib/ft6336;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ./: img_emoji_F617.c
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lvgl/config
    ../My_Lib/lvgl8.3/: lv_conf.h lvgl.h
  group lvgl/demo
    ../My_Lib/lvgl8.3/demo/: my_lv.c
  group lvgl/porting
    ../My_Lib/lvgl8.3/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl/src/config
    ../My_Lib/lvgl8.3/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/src/core
    ../My_Lib/lvgl8.3/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../My_Lib/lvgl8.3/src/draw/arm2d/: lv_gpu_arm2d.c
    ../My_Lib/lvgl8.3/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../My_Lib/lvgl8.3/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../My_Lib/lvgl8.3/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../My_Lib/lvgl8.3/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../My_Lib/lvgl8.3/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../My_Lib/lvgl8.3/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../My_Lib/lvgl8.3/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../My_Lib/lvgl8.3/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../My_Lib/lvgl8.3/src/extra/: lv_extra.c
    ../My_Lib/lvgl8.3/src/extra/layouts/flex/: lv_flex.c
    ../My_Lib/lvgl8.3/src/extra/layouts/grid/: lv_grid.c
    ../My_Lib/lvgl8.3/src/extra/libs/bmp/: lv_bmp.c
    ../My_Lib/lvgl8.3/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../My_Lib/lvgl8.3/src/extra/libs/freetype/: lv_freetype.c
    ../My_Lib/lvgl8.3/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../My_Lib/lvgl8.3/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../My_Lib/lvgl8.3/src/extra/libs/png/: lodepng.c lv_png.c
    ../My_Lib/lvgl8.3/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../My_Lib/lvgl8.3/src/extra/libs/rlottie/: lv_rlottie.c
    ../My_Lib/lvgl8.3/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../My_Lib/lvgl8.3/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../My_Lib/lvgl8.3/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../My_Lib/lvgl8.3/src/extra/others/gridnav/: lv_gridnav.c
    ../My_Lib/lvgl8.3/src/extra/others/ime/: lv_ime_pinyin.c
    ../My_Lib/lvgl8.3/src/extra/others/imgfont/: lv_imgfont.c
    ../My_Lib/lvgl8.3/src/extra/others/monkey/: lv_monkey.c
    ../My_Lib/lvgl8.3/src/extra/others/msg/: lv_msg.c
    ../My_Lib/lvgl8.3/src/extra/others/snapshot/: lv_snapshot.c
    ../My_Lib/lvgl8.3/src/extra/themes/basic/: lv_theme_basic.c
    ../My_Lib/lvgl8.3/src/extra/themes/default/: lv_theme_default.c
    ../My_Lib/lvgl8.3/src/extra/themes/mono/: lv_theme_mono.c
    ../My_Lib/lvgl8.3/src/extra/widgets/animimg/: lv_animimg.c
    ../My_Lib/lvgl8.3/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../My_Lib/lvgl8.3/src/extra/widgets/chart/: lv_chart.c
    ../My_Lib/lvgl8.3/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../My_Lib/lvgl8.3/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../My_Lib/lvgl8.3/src/extra/widgets/keyboard/: lv_keyboard.c
    ../My_Lib/lvgl8.3/src/extra/widgets/led/: lv_led.c
    ../My_Lib/lvgl8.3/src/extra/widgets/list/: lv_list.c
    ../My_Lib/lvgl8.3/src/extra/widgets/menu/: lv_menu.c
    ../My_Lib/lvgl8.3/src/extra/widgets/meter/: lv_meter.c
    ../My_Lib/lvgl8.3/src/extra/widgets/msgbox/: lv_msgbox.c
    ../My_Lib/lvgl8.3/src/extra/widgets/span/: lv_span.c
    ../My_Lib/lvgl8.3/src/extra/widgets/spinbox/: lv_spinbox.c
    ../My_Lib/lvgl8.3/src/extra/widgets/spinner/: lv_spinner.c
    ../My_Lib/lvgl8.3/src/extra/widgets/tabview/: lv_tabview.c
    ../My_Lib/lvgl8.3/src/extra/widgets/tileview/: lv_tileview.c
    ../My_Lib/lvgl8.3/src/extra/widgets/win/: lv_win.c
  group lvgl/src/font
    ../My_Lib/lvgl8.3/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/hal
    ../My_Lib/lvgl8.3/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../My_Lib/lvgl8.3/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../My_Lib/lvgl8.3/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group st7789v
    ../My_Lib/st7789v/: st7789v.c
  group ft6336
    ../My_Lib/ft6336/: ft6336.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
